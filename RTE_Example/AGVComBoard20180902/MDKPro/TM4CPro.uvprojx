# Keil uVision project TM4CPro.uvprojx, settings and files
target TM4C1294 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4CPro
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT __FPU_PRESENT __TARGET_FPU_VFP DEBUG_USART=UART0_BASE __RTX
  c include: ..\TI_DriveLib\inc;..\SL_RTE2.1\RTE_APP;..\SL_RTE2.1\RTE_Board\General_TM4C;..\SL_RTE2.1\RTE_Config;..\CAN_APP;..\RL_NET;..\XML_Lib;..\HTTP_Lib;..\WEBSERVICE_APP;..\TCP_APP;..\AGV_APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Main
    ../Main/: main.c
  group TivaWareLib
    ../TI_DriveLib/src/: can.c cpu.c eeprom.c emac.c gpio.c hibernate.c sysctl.c systick.c uart.c watchdog.c interrupt.c sw_crc.c flash.c
  group RTE_APP
    ../SL_RTE2.1/RTE_APP/: RTE_BGet.c RTE_Core.c RTE_KVDB.c RTE_RetargetIO.c RTE_RingQuene.c RTE_RoundRobin.c RTE_Shell.c RTE_StateMachine.c RTE_Stdio.c RTE_Stdlib.c
  group RTE_BSP
    ../SL_RTE2.1/RTE_Board/General_TM4C/: BSP_Led.c BSP_Systick.c BSP_Interrupt.c BSP_Com.c BSP_Flash.c BSP_CAN.c BSP_WatchDog.c BSP_ETH.c BSP_Time.c
  group RTE_Config
    ../SL_RTE2.1/RTE_Config/: RTE_Config.h
  group CAN_APP
    ../CAN_APP/: CAN_STATE.c CAN_SEND.c
  group AGV_APP
    ../AGV_APP/: AGV_SM.c
  group TCP_APP
    ../TCP_APP/: TCP_Client.c TCP_Server.c
  group WEBSERVICE_APP
    ../WEBSERVICE_APP/: WebService_Parser.c WebService_SoapFuncionName.c WebService_Send.c
  group RL_NET
    ../RL_NET/: TCP_CM3.lib Net_Config.c
  group XML_Lib
    ../XML_Lib/: mxml-attr.c mxml-entity.c mxml-file.c mxml-get.c mxml-index.c mxml-node.c mxml-private.c mxml-search.c mxml-set.c mxml-string.c
  group HTTP_Lib
    ../HTTP_Lib/: http_send.c http_string.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup 1.0.0
