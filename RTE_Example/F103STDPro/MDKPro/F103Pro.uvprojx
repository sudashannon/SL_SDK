# Keil uVision project F103Pro.uvprojx, settings and files
target F103C8T (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103Pro
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,STM32F1
  c include: ..\SL_RTE\SL_APP;..\SL_RTE\SL_BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c stm32f10x_it.c
  group SL_RTE/APP
    ../SL_RTE/SL_APP/: APP_F1.c APP_SoftTimer.c APP_BGet.c APP_RingBuffer.c APP_String.c APP_StateMachine.c APP_Debug.c APP_Cmdline.c
  group SL_RTE/BSP
    ../SL_RTE/SL_BSP/: BSP_Led.c BSP_Key.c BSP_ComF1.c
  group SL_RTE/Config
    ../SL_RTE/SL_APP/: APP_Config.h
    ../SL_RTE/SL_BSP/: BSP_Config.h
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
