# Keil uVision project cam_h7.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cam_h7
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=1
  c define: USE_HAL_DRIVER, STM32H743xx, RTE_MEMPOOL_SIZE=256*1024, RTE_MEMPOOL_USE_64BIT=0,LV_CONF_INCLUDE_SIMPLE=1
  c include: ..\..\inc;..\..\src\utils\letter-shell\src;.\user_app;.\user_bsp;..\..\src\utils\lvgl;..\stm32_h7_full_demo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\cam_h7.sct
  group user_apps
    ../: rte_adapter_cmsis_rtos2.c
    ./user_app/: system_thread.c gui_thread.c
  group user_bsps
    ./user_bsp/: bsp_lcd.c bsp_sensor.c ov2640.c ov7725.c
  group STM32CubeMX:BSP Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: gpio.c usart.c dma.c spi.c i2c.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group rte_middlelayer
    ../../src/middleware/: rte_log.c rte_memory.c rte_timer.c
  group rte_hal
    ../../src/hal/: hal_gpio_stm32h7.c hal_key.c hal_com_stm32h7.c hal_spi_stm32h7.c
  group rte_datastructure
    ../../src/data_structure/: ds_hashmap.c ds_linklist.c ds_ringbuffer.c ds_vector.c ds_framebuffer.c ds_image.c
  group rte_utils/lvgl
    ../../src/utils/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../src/utils/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../src/utils/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../src/utils/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../src/utils/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../src/utils/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../src/utils/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../src/utils/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../src/utils/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../src/utils/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../src/utils/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../src/utils/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../src/utils/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../src/utils/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../src/utils/lvgl/src/extra/widgets/led/: lv_led.c
    ../../src/utils/lvgl/src/extra/widgets/list/: lv_list.c
    ../../src/utils/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../src/utils/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../src/utils/lvgl/src/extra/widgets/span/: lv_span.c
    ../../src/utils/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../src/utils/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../src/utils/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../src/utils/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../src/utils/lvgl/src/extra/widgets/win/: lv_win.c
    ../../src/utils/lvgl/src/extra/: lv_extra.c
    ../../src/utils/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../src/utils/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../../src/utils/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../src/utils/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../src/utils/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group rte_utils/letter-shell
    ../../src/utils/letter-shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:DMA 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:I2C 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:STM32Cube HAL:SPI 1.8.0, Device:STM32Cube HAL:UART 1.8.0, Device:Startup 1.8.0
