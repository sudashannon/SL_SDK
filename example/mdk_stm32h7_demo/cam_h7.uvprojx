# Keil uVision project cam_h7.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: cam_h7
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: STM32H743xx, RTE_MEMPOOL_SIZE=256*1024, RTE_MEMPOOL_USE_64BIT=0,LV_CONF_INCLUDE_SIMPLE=1, LV_LVGL_H_INCLUDE_SIMPLE=1
  c include: ..\..\rte\inc;..\..\hal\inc;.\user_app;.\user_bsp;..\stm32_h7_full_demo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\cam_h7.sct
  group user_apps
    ../: rte_adapter_cmsis_rtos2.c
    ./user_app/: system_thread.c gui_thread.c sensor_thread.c
  group user_bsps
    ./user_bsp/: bsp_lcd.c bsp_sensor.c ov2640.c ov7725.c bsp_jpege.c
  group STM32CubeMX:BSP Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: gpio.c usart.c dma.c spi.c i2c.c dcmi.c quadspi.c jpeg.c mdma.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group middlelayer
    ../../rte/src/middleware/: rte_log.c rte_memory.c rte_timer.c
  group hal
    ../../hal/src/: hal.c hal_com_stm32h7.c hal_gpio_stm32h7.c hal_key.c hal_qspi_stm32h7.c hal_spi_stm32h7.c
  group datastructure
    ../../rte/src/data_structure/: ds_hashmap.c ds_linklist.c ds_ringbuffer.c ds_vector.c
  group imageprocess
    ../../rte/src/image_process/: binary.c denoise.c edge.c filter.c font.c hough.c image_base.c sincos_tab.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DCMI 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:JPEG 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:QSPI 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
